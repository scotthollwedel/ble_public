# Keil uVision project ble_app_ibeacon.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_ibeacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;C:\Keil\ARM\Device\Nordic\nrf51822\Include;C:\Keil\ARM\Device\Nordic\nrf51822\Include\app_common;C:\Keil\ARM\Device\Nordic\nrf51822\Include\ble;C:\Keil\ARM\Device\Nordic\nrf51822\Include\ble\ble_services;C:\Keil\ARM\Device\Nordic\nrf51822\Include\s110;C:\Keil\ARM\Device\Nordic\nrf51822\Include\sd_common;C:\Keil\ARM\Device\Nordic\nrf51822\Include\ext_sensors;C:\Keil\ARM\Device\Nordic\nrf51822\Include\esb
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/: ble_advdata.c ble_debug_assert_handler.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ext_sensors/nRF6350/: nRF6350.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/twi_master/: twi_hw_master.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/app_common/: app_button.c app_timer.c app_gpiote.c app_scheduler.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Board/nrf6310/s120/experimental/common/: debug.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_ibeacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: ble_app_ibeacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BOARD_NRF6310  DEBUG_NRF_USER S120_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..;C:\Keil\ARM\Device\Nordic\nrf51822\Include;C:\Keil\ARM\Device\Nordic\nrf51822\Include\app_common;C:\Keil\ARM\Device\Nordic\nrf51822\Include\ble;C:\Keil\ARM\Device\Nordic\nrf51822\Include\ble\ble_services;C:\Keil\ARM\Device\Nordic\nrf51822\Include\s120;C:\Keil\ARM\Device\Nordic\nrf51822\Include\sd_common;C:\Keil\ARM\Device\Nordic\nrf51822\Include\ext_sensors;C:\Keil\ARM\Device\Nordic\nrf51822\Include\esb;C:\Keil\ARM\Device\Nordic\nrf51822\Board\nrf6310\s120\experimental\common;C:\Keil\ARM\Device\Nordic\nrf51822\Board\nrf6310\s120\experimental\
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
