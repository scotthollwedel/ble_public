# Keil uVision project zeus.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: zeus +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: C:\Keil\ARM\Device\Nordic\nrf51822\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/templates/: system_nrf51.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group Source
    ./: main.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/: keil_arm_uv4.lnt
  group Libs
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/nrf_delay/: nrf_delay.c
